# Keil uVision project proj_rcu.uvprojx, settings and files
target proj_rcu (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: proj_rcu
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe -c -e -o @L.lst !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CORTEX_M4F __FPU_PRESENT=1 __CMSIS_RTOS DBG_MSG MSRCU
  c misc: --diag_suppress 3731 --bss_threshold=0
  c include: ..\..\..\common\ARM\CMSIS\Include;..\..\..\common\inc;..\..\..\..\ble_if\inc;..\..\..\..\inc;..\..\..\..\inc\hal;..\..\..\..\spi_flash\inc;..\..\..\..\bootloader\inc;..\..\..\..\RF;..\..\..\..\thirdparty\rtx\src;..\..\..\..\thirdparty\rtx\inc;..\..\inc;..\..\inc\msrcu_app;..\..\inc\msrcu_firmware;..\..\inc\msrcu_device\tspa4c500a;..\..\inc\msrcu_peripheral\sensor;..\..\inc\msrcu_common;..\..\inc\msrcu_algorithm
  asm define: __CMSIS_RTOS
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x20000
  scatter file: .\proj_rcu.sct
  group startup
    ../../../../startup/: system_inxxx.c startup_inxxx.s
  group spi_flash
    ../../../../spi_flash/src/: spi_flash.c
  group lib
    ../../../../lib/rom/: ble_rom.lib ble_flash.lib
    ../../../../lib/: rf.lib
    ../../../../lib/prf/: inb_prf_bas.lib inb_prf_dis.lib inb_prf_hog.lib
  group hal
    ../../../../hal/: hal_uart.c hal_clk.c hal_gpio.c hal_audio.c hal_counter.c hal_ir.c hal_keyboard.c hal_smem.c hal_global.c hal_dma.c hal_i2c.c hal_power.c hal_spi_flash.c hal_timer.c hal_adc.c hal_efuse.c
  group ble_if
    ../../../../ble_if/src/: inb_config.c inb_plt.c
  group profile
    ../../src/: prf_atv.c prf_atv_task.c
    ../../../common/ble/ota/: prf_otas.c
  group main
    ../../src/: main.c
    ../../../common/ARM/: RTX_Conf_CM.c Retarget.c
    ../../../common/util/: msg.c
    ../../../common/ble/evt/: gap_evt.c gatt_evt.c bas_evt.c dis_evt.c hogp_evt.c
    ../../../common/ble/: ble_app.c
  group thirdparty_rtx
    ../../../../thirdparty/rtx/src/ARM/: SVC_Table.s HAL_CM4.c
    ../../../../thirdparty/rtx/src/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group thirdparty_segger
    ../../../../thirdparty/segger/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group msrcu_lib
    ../../lib/: msrcu.lib
  group msrcu_app
    ../../src/msrcu_app/: msrcu_app.c
    ../../inc/msrcu_app/: msrcu_app.h
  group msrcu_firmware
    ../../src/msrcu_firmware/: msrcu_fw_device.c msrcu_fw_ble.c msrcu_fw_led.c msrcu_fw_key.c msrcu_fw_voice.c msrcu_fw_motion.c msrcu_fw_ir.c
    ../../inc/msrcu_firmware/: msrcu_fw_device.h msrcu_fw_ble.h msrcu_fw_led.h msrcu_fw_key.h msrcu_fw_voice.h msrcu_fw_motion.h msrcu_fw_ir.h
  group msrcu_device_tspa4c500a
    ../../src/msrcu_device/tspa4c500a/: msrcu_dev_system.c msrcu_dev_ble.c msrcu_dev_gpio.c msrcu_dev_keyboard.c msrcu_dev_audio.c msrcu_dev_i2c.c msrcu_dev_adc.c
    ../../inc/msrcu_device/tspa4c500a/: msrcu_dev_system.h msrcu_dev_ble.h msrcu_dev_gpio.h msrcu_dev_keyboard.h msrcu_dev_audio.h msrcu_dev_i2c.h msrcu_dev_ir.h msrcu_dev_adc.h
  group msrcu_peripheral_sensor
    ../../src/msrcu_peripheral/sensor/: bmi160.c
    ../../inc/msrcu_peripheral/sensor/: bmi160.h bmi160_defs.h
  group msrcu_algorithm
    ../../inc/msrcu_algorithm/: airmouse.h
  group msrcu_common
    ../../inc/msrcu_common/: msrcu_event.h msrcu_common.h msrcu_ble.h msrcu_debug.h msrcu_error.h msrcu_config.h
    ../../src/msrcu_common/: msrcu_config.c
