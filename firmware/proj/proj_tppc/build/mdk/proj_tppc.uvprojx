# Keil uVision project proj_tppc.uvprojx, settings and files
target proj_tppc (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: proj_tppc
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe -c -e -o @L.lst !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CORTEX_M4F __FPU_PRESENT=1 __CMSIS_RTOS DBG_MSG CFG_PROJ_TPPC
  c misc: --diag_suppress 3731 --bss_threshold=0
  c include: ..\..\..\common\ARM\CMSIS\Include;..\..\..\common\inc;..\..\..\..\ble_if\inc;..\..\..\..\inc;..\..\..\..\inc\hal;..\..\..\..\spi_flash\inc;..\..\..\..\bootloader\inc;..\..\..\..\RF;..\..\..\..\thirdparty\rtx\src;..\..\..\..\thirdparty\rtx\inc;..\..\inc
  asm define: __CMSIS_RTOS
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x20000
  scatter file: .\proj_tppc.sct
  link misc: ..\..\..\..\lib\rf.lib
..\..\..\..\lib\rom\ble_flash.lib
..\..\..\..\lib\rom\ble_rom.lib
  group startup
    ../../../../startup/: system_inxxx.c startup_inxxx.s
  group spi_flash
    ../../../../spi_flash/src/: spi_flash.c
  group hal
    ../../../../hal/: hal_uart.c hal_clk.c hal_gpio.c hal_smem.c hal_global.c hal_power.c hal_timer.c hal_dma.c
  group ble_if
    ../../../../ble_if/src/: inb_config.c inb_plt.c
  group profile_tpp
    ../../src/: prf_tppc.c
  group main
    ../../src/: main.c
    ../../../common/ARM/: RTX_Conf_CM.c Retarget.c
    ../../../common/evt/: l2cc_evt.c gap_evt.c gatt_evt.c
    ../../../common/test/: test_svc.c ble_test.c
    ../../../common/util/: msg.c
  group thirdparty_rtx
    ../../../../thirdparty/rtx/src/ARM/: SVC_Table.s HAL_CM4.c
    ../../../../thirdparty/rtx/src/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group thirdparty_segger
    ../../../../thirdparty/segger/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.0.2
