# Keil uVision project msrcu.uvprojx, settings and files
target msrcu (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: msrcu (library)
  AfterMake: cmd.exe /C copy .\Objects\msrcu.lib ..\..\..\lib\
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\common\ARM\CMSIS\Include;..\..\..\..\common\inc;..\..\..\..\..\inc;..\..\..\..\..\thirdparty\rtx\inc;..\..\..\..\..\inc\hal;..\..\..\inc\msrcu_device\tspa4c500a;..\..\..\inc\msrcu_common;..\..\..\inc\msrcu_algorithm
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group device_tspa4c500a
    ../../../src/msrcu_device/tspa4c500a/: msrcu_dev_audio.c msrcu_dev_ir.c
  group algorithm
    ../../../src/msrcu_algorithm/: airmouse.c
