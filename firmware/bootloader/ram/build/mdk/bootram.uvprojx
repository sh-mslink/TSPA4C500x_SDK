# Keil uVision project bootram.uvprojx, settings and files
target bootram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: bootram
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe -c -e -o @L.lst !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_SIMU=0
  c include: ..\..\..\..\spi_flash\inc;..\..\..\inc;..\..\..\..\inc;..\..\inc
  memory RVCT4: ROM 0x200000 size 0x800
  memory RVCT9: RAM 0x200800 size 0x400
  scatter file: .\bootram.sct
  link misc: --entry=boot_ram_entry --keep=ram_entry.o(BOOTCFG)
..\..\lib\rom_c.lib
  group src
    ../../src/: ram_entry.c
    ../../../../spi_flash/src/: spi_flash.c
target bootram_no_ext_flash (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: bootram_no_ext_flash
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe -c -e -o @L.lst !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_SIMU=0
  c include: ..\..\..\..\spi_flash;..\..\..\inc;..\..\..\..\inc
  memory RVCT4: ROM 0x200000 size 0x800
  memory RVCT9: RAM 0x200800 size 0x400
  scatter file: .\bootram_no_ext_flash.sct
  link misc: --entry=boot_ram_entry
software components: CMSIS:CORE 4.3.0
